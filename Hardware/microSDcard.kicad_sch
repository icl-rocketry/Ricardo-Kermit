File: Hardware/microSDcard.kicad_sch (KiCad schematic)
At the start: 3 parts, among them J16 Micro_SD_Card_Det

Commit message: Start work
Parts:
- renumbered C10 to C90
